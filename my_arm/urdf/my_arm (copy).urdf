Commit message: implemented moveit and roscontrol

File: my_arm/urdf/my_arm (copy).urdf (robot description, URDF)
Before this commit: robot my_arm, 8 links, 7 joints
Links:
- removed link world
- added link base_link
Joints:
- joint base2base_joint: parent world -> base_link
